Commit message: add two roller env

File: examples/objects/curved_cube.urdf (robot description, URDF)
Before this commit: robot box2D, 1 links, 0 joints
Links:
- link baselink: geometry collision mesh filename=curved_cube.obj scale=1 1 1; visual mesh filename=curved_cube.obj scale=1 1 1
